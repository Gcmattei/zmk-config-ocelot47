## boards/shields/ocelot47/Kconfig.defconfig
```kconfig
if SHIELD_OCELOT47

config ZMK_KEYBOARD_NAME
    default "ocelot47"

endif # SHIELD_OCELOT47
```
